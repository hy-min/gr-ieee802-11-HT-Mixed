options:
  parameters:
    author: hy
    generate_options: qt_gui
    id: test1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: 10e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 10e6
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: wifi_phy_ht_hier_0
  id: wifi_phy_ht_hier
  parameters:
    bandwidth: 10e6
    chan_est: ieee802_11.LS
    encoding: ieee802_11.BPSK_1_2
    frequency: 5.89e9
    sensitivity: '0.56'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', wifi_phy_ht_hier_0, in]
- [wifi_phy_ht_hier_0, out, qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
